## boards/Ondera/tanksense/board.yml
```yaml
board:
  name: tanksense
  full_name: tanksense
  vendor: Ondera
  socs:
    - name: nrf52840
```
